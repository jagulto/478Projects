# Keil uVision project switch_delay_interrupt.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: switch_delay_interrupt
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ../../../../driverlib/rvmdk/: driverlib.lib
    ./: switch_delay_interrupt.c startup_rvmdk.S
software components: CMSIS:CORE 5.3.0

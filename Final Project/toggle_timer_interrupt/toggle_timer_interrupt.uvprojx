# Keil uVision project toggle_timer_interrupt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: toggle_timer_interrupt
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..\..\..;C:\ti\TivaWare_C_Series-2.1.4.178;Z:\driverlib;Z:\ti\TivaWare_C_Series-2.1.4.178\utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S toggle_timer_interrupt.c
    Z:/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
software components: CMSIS:CORE 5.3.0
